# Keil uVision project TIM.uvprojx, settings and files
target TIM (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TIM
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: STM32F103xB, USE_FULL_LL_DRIVER
  c include: .\STM32F1xx_HAL_Driver\Inc;.\STM32F1xx\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./src/: main.c
  group Device
    ./STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ./STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group LL_driver
    ./STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDOUT 1.2.0
